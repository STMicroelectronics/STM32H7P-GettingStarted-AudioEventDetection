# IAR project STM32H7P-GettingStarted-AED.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7P5II ST STM32H7P5II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7P5xx; _RTE_; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32H7P; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1; USE_HAL_DRIVER; HAVE_NETWORK_INFO; USE_HSP; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ../../../stm32cubefw_h7p/stm32h7pxx_drivers/os_port/no_os; ../../../stm32cubefw_h7p/stm32h7pxx_dfp/Include; ../../../stm32cubefw_h7p/arch/cmsis/CMSIS/Core/Include; ../../../stm32cubefw_h7p/stm32h7pxx_drivers/hal; ../../../stm32cubefw_h7p/stm32h7pxx_drivers/ll; ../../../stm32cubefw_h7p/arch/cmsis_dsp/Include; ../../../Middlewares/stedgeai-lib/Npu/ll_aton; ../../../Middlewares/stedgeai-lib/Npu/Devices/STM32H7xx; ../../../Middlewares/stedgeai-lib/Inc; ../../../Middlewares/ST/stm32-audio-sensing-processing/Inc; ../../../stm32cubefw_h7p/middleware/hsp_engine/interfaces; ../../../stm32cubefw_h7p/middleware/hsp_engine/common/core; ../../../stm32cubefw_h7p/middleware/hsp_engine/common/proclist; ../../../stm32cubefw_h7p/middleware/hsp_engine/common/modules/proclist_lib; ../../../stm32cubefw_h7p/middleware/hsp_engine/common/modules/direct_lib; ../../../stm32cubefw_h7p/middleware/hsp_engine/common/modules/cnn_lib; ../../../stm32cubefw_h7p/middleware/hsp_engine/common/modules/dsp_lib; ../../../stm32cubefw_h7p/middleware/hsp_engine/common/modules/firmware; ../../../stm32cubefw_h7p/middleware/hsp_engine/common/modules/firmware/crom_1.1.7/cram_1.6; ../../../stm32cubefw_h7p/middleware/hsp_engine/common/modules; ../../../stm32cubefw_h7p/middleware/hsp_engine/common/utilities; ../../../model; ../application/core; ../application/hsp_engine; ../application/audioPipeline
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H7P-GettingStarted-AED.hex
  ILINK.IlinkOutputFile: STM32H7P-GettingStarted-AED.out
  ILINK.IlinkIcfFile: stm32h7pxxi_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../Middlewares/stedgeai-lib/Lib/ABI2.1/ARMCortexM7/NetworkRuntime1102_CM7_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group AI
    ../../../Middlewares/stedgeai-lib/Npu/Devices/STM32H7xx/: mcu_cache.c
  group AI/ll_aton
    ../../../Middlewares/stedgeai-lib/Npu/ll_aton/: ecloader.c ll_aton.c ll_aton_cipher.c ll_aton_dbgtrc.c ll_aton_debug.c ll_aton_lib.c ll_aton_lib_sw_operators.c ll_aton_runtime.c ll_aton_stai_internal.c ll_aton_util.c ll_sw_float.c ll_sw_integer.c
  group AI/model
    ../../../model/: network.c network_data.c stai_network.c
  group application/audioPipeline
    ../application/core/: ai_device_adaptor.c aiTestHelper_ST_AI.c lc_print.c
    ../../../Middlewares/stedgeai-lib/Misc/Src/: aiTestUtility.c
    ../application/audioPipeline/: audiopipeline_ai.c audiopipeline_preproc.c user_mel_tables.c
  group application/Core
    ../application/core/: app_audio.c cpu_stats.c gs_utils.c logging.c stm32h7pxx_it.c
  group CMSIS
    ../../../stm32cubefw_h7p/arch/cmsis_dsp/Source/TransformFunctions/: arm_bitreversal2.c arm_cfft_f32.c arm_cfft_init_f32.c arm_cfft_radix8_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
    ../../../stm32cubefw_h7p/arch/cmsis_dsp/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c arm_cmplx_mag_squared_f32.c
    ../../../stm32cubefw_h7p/arch/cmsis_dsp/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../../../stm32cubefw_h7p/arch/cmsis_dsp/Source/BasicMathFunctions/: arm_dot_prod_f32.c arm_mult_f32.c
    ../../../stm32cubefw_h7p/arch/cmsis_dsp/Source/SupportFunctions/: arm_q15_to_float.c
  group hsp_engine/Interfaces
    ../../../stm32cubefw_h7p/middleware/hsp_engine/interfaces/: hsp_bram_if.c hsp_hw_if.c
  group hsp_engine/Middleware
    ../../../stm32cubefw_h7p/middleware/hsp_engine/common/core/: hsp_bram.c hsp_core.c
  group hsp_engine/Modules
    ../../../stm32cubefw_h7p/middleware/hsp_engine/common/modules/direct_lib/: hsp_direct_command.c
  group hsp_engine/Utilities
    ../../../stm32cubefw_h7p/middleware/hsp_engine/common/utilities/: hsp_memcpy.c
    ../../../stm32cubefw_h7p/middleware/hsp_engine/common/utilities/portable/IAR/: st_hsp_memcpy32.s
  group stm32-audio-sensing-processing
    ../../../Middlewares/ST/stm32-audio-sensing-processing/Src/: audio_din.c feature_extraction.c mel_filterbank.c
  group stm32h7pxx_drivers/hal
    ../../../stm32cubefw_h7p/stm32h7pxx_drivers/hal/: stm32h7pxx_hal.c stm32h7pxx_hal_adf.c stm32h7pxx_hal_cortex.c stm32h7pxx_hal_dma.c stm32h7pxx_hal_flash.c stm32h7pxx_hal_flash_itf.c stm32h7pxx_hal_gpio.c stm32h7pxx_hal_hsp.c stm32h7pxx_hal_pwr.c stm32h7pxx_hal_q.c stm32h7pxx_hal_rcc.c stm32h7pxx_hal_tim.c stm32h7pxx_hal_uart.c
  group stm32h7pxx_drivers/os_port
    ../../../stm32cubefw_h7p/stm32h7pxx_drivers/os_port/no_os/: stm32_hal_os.c
  group System
    ../../../stm32cubefw_h7p/stm32h7pxx_dfp/Source/: startup_stm32h7p5xx.c
    ../../../stm32cubefw_h7p/stm32h7pxx_dfp/Source/Templates/: system_stm32h7pxx.c
  group UserCode
    ../application/core/: main.c
